# IAR project SENSORMDK.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\CMSIS; ..\Components\sprintf; ..\Components\USART; ..\Components\ActiveHalt; ..\STM8L15x_StdPeriph_Driver\inc; ..\STM8L15x_StdPeriph_Driver\src; ..\system; E:\PROJECT\gas\client_stm8\SENSOR_send\Components; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\ActiveHalt; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\DATA; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\ETC; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\HX712; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\SPI; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\sprintf; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\SX1212; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\USART; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\Timer; E:\PROJECT\gas\client_stm8\SENSOR_send\Components\RFM64
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SENSORMDK.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group CMSIS
    ../CMSIS/: stm8l15x.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
  group Components
    ../Components/ActiveHalt/: ActiveHalt.c
    ../Components/DATA/: data.c data.h
    ../Components/ETC/: ETC.c
    ../Components/HX712/: HX712.c
    ../Components/: MyTypeDef.h
    ./: program.c
    ../Components/RFM64/: Rfm64.c
    ../Components/SPI/: SPI.c
    ../Components/sprintf/: sprintf.c
    ../Components/SX1212/: SX1212.c
    ../Components/Timer/: timer.c
    ../Components/USART/: USART.c
  group LIB
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_itc.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c
  group Readme
    ../READ ME/: read me.txt
  group System
    ../system/: delay.c rtc.c
